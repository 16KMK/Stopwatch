# file: Stop Watch.ioc
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Mcu.Family=STM32F1
Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.APB1Freq_Value=8000000
RCC.APB2Freq_Value=8000000
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
 ******************************************************************************
 * @file           : main.c
 * @brief          : Main program body
 ******************************************************************************
 * @attention
 *
 * Copyright (c) 2024 STMicroelectronics.
 * All rights reserved.
 *
 * This software is licensed under terms that can be found in the LICENSE file
 * in the root directory of this software component.
 * If no LICENSE file comes with this software, it is provided AS-IS.
 *
 ******************************************************************************
 */
/* USER CODE END Header */
#include "main.h"

/* USER CODE BEGIN PV */
Keypad_Matrix_t matrix1 = { .Row_Port = GPIOB, .Row_Start_Pin = 12,
		.Column_Port = GPIOB, .Column_Start_Pin = 6, .Rows = 4, .Columns = 4 };
Alcd_t lcd1 = { .Data_GPIO = GPIOA, .Data_GPIO_Start_Pin = 0, .RS_GPIO = GPIOA,
		.RS_GPIO_Pin = GPIO_PIN_4, .EN_GPIO = GPIOA, .EN_GPIO_Pin = GPIO_PIN_5 };
GPIO_InitTypeDef FGC = { .Mode = GPIO_MODE_OUTPUT_PP, .Speed = GPIO_SPEED_LOW,
		.Pin = GPIO_PIN_13 };
char str[16];
uint8_t HH = 00;
uint8_t MM = 00;
uint8_t SS = 00;
uint8_t MS = 00;
uint8_t x;
/* USER CODE END PV */

void SystemClock_Config(void);
static void MX_GPIO_Init(void);

int main(void) {

	/* MCU Configuration--------------------------------------------------------*/

	/* Reset of all peripherals, Initializes the Flash interface and the Systick. */
	HAL_Init();

	/* Configure the system clock */
	SystemClock_Config();

	/* Initialize all configured peripherals */
	MX_GPIO_Init();

	/* USER CODE BEGIN 2 */
	__HAL_RCC_GPIOA_CLK_ENABLE();
	__HAL_RCC_GPIOB_CLK_ENABLE();
	Alcd_Init(&lcd1, 2, 16);
	Keypad_Matrix_init(&matrix1);

	/* USER CODE END 2 */

	/* Infinite loop */
	/* USER CODE BEGIN WHILE */
	while (1) {
		Keypad_Matrix_Refresh(&matrix1);
		//Key_0 for Start
		if (Keypad_Matrix_ReadKey(&matrix1, 0)) {
			x = 0;
		}

		//Key_1 for stop
		else if (Keypad_Matrix_ReadKey(&matrix1, 1)) {
			x = 1;
		}

		//Key_2 for clear
		else if (Keypad_Matrix_ReadKey(&matrix1, 2)) {
			x = 2;
		}
		HAL_Delay(100);
		uint8_t length = sprintf(str, "%02d:%02d:%02d:%02d", HH, MM, SS, MS);
		Alcd_PutAt_n(&lcd1, 0, 0, str, length);
		if (x == 1) {
			MS++;
			if (MS == 10) {
				SS++;
				MS = 0;
			}

			if (SS == 59)

			{
				MM++;
				MS = 0;
				SS = 0;
			}
			if (MM == 59)

			{
				HH++;
				MS = 0;
				MM = 0;
				SS = 0;
			} else if (HH == 23) {
				HH = 0;
				MM = 0;
				SS = 0;
				MS = 0;

			}

		} else if (x == 1) {

		} else if (x == 2)

		{
			HH = 0;
			MM = 0;
			SS = 0;
			MS = 0;
		}
		/* USER CODE END WHILE */
	}
	/* USER CODE BEGIN 3 */
}
/* USER CODE END 3 */

void SystemClock_Config(void) {
	RCC_OscInitTypeDef RCC_OscInitStruct = { 0 };
	RCC_ClkInitTypeDef RCC_ClkInitStruct = { 0 };

	/** Initializes the RCC Oscillators according to the specified parameters
	 * in the RCC_OscInitTypeDef structure.
	 */
	RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
	RCC_OscInitStruct.HSEState = RCC_HSE_ON;
	RCC_OscInitStruct.HSEPredivValue = RCC_HSE_PREDIV_DIV1;
	RCC_OscInitStruct.HSIState = RCC_HSI_ON;
	RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
	RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
	RCC_OscInitStruct.PLL.PLLMUL = RCC_PLL_MUL9;
	if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK) {
		Error_Handler();
	}

	/** Initializes the CPU, AHB and APB buses clocks
	 */
	RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK | RCC_CLOCKTYPE_SYSCLK
			| RCC_CLOCKTYPE_PCLK1 | RCC_CLOCKTYPE_PCLK2;
	RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
	RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
	RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV2;
	RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

	if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_2) != HAL_OK) {
		Error_Handler();
	}
}

static void MX_GPIO_Init(void) {

	/* GPIO Ports Clock Enable */
	__HAL_RCC_GPIOD_CLK_ENABLE();
	__HAL_RCC_GPIOA_CLK_ENABLE();

}

void Error_Handler(void) {
	__disable_irq();
	while (1) {
	}
}
